# Keil uVision project SDP800_SampleCode.uvproj, settings and files
target SDP800 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SDP800_SampleCode +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./Source/: startup_stm32f10x_md_vl.s
  group Source Files
    ./Source/: main.c i2c_hal.c i2c_hal.h system.c system.h sdp800.c sdp800.h
